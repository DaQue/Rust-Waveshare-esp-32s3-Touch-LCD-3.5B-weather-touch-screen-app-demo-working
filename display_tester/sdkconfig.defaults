## display_tester/sdkconfig.defaults
```kconfig
# Increase main task stack for Rust std runtime
CONFIG_ESP_MAIN_TASK_STACK_SIZE=16384
```
